Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2017-02-16T14:46:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Thu Feb 16 14:46:34 2017* Host: NCL-PI12* Database: C:\Users\KunduR\AppData\Local\Temp\{330A7675-F01D-4107-BCEC-A93C8307A4E4}\ifc* Database version: 5507* Database creation date: Thu Feb 16 14:46:33 2017* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Thu Feb 16 14:46:34 2017* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Thu Feb 16 14:46:34 2017* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFurnishingElement: 20Ltr, NBS_FCFrostLtd_WasteBins_UndercounterRunnerWasteBin:20Ltr:299767
In: Level 0
Type - ElementType: 20Ltr; Classification: Pr_40_50_07_96 (Uniclass2015); Material: NBS_Concept
Type - NBS_General - Author: NBS; BIMObjectName: NBS_FCFrostLtd_WasteBins_UndercounterRunnerWasteBin_20Ltr; ManufacturerName: FC Frost Ltd; ManufacturerURL: www.fcfrost.com; NBSCertification: www.nationalbimlibrary.com/cert/skzuu4ga; NBSDescription: Waste bins; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 45-35-72/380; NBSTypeID: n/a; ProductInformation: www.fcfrost.com/09.1150.html; Revision: n/a; Uniclass2015Code: Pr_40_50_07_96; Uniclass2015Title: Waste bins; Uniclass2015Version: Products v1.5; Version: 1
Type - NBS_Data - EnvironmentalProductDeclaration: n/a; Form: Undercounter; IntegralAccessories: n/a; Capacity: 20 litres; SizeOptions: Bins can be made to suit customer’s dimensional requirements; StucturalOpeningSizeRecommendation: n/a; RecommendedMountingHeight: n/a; Spares: Contact FC Frost for spares requirements: service@fcfrost.com
Type - Pset_FurnitureTypeCommon - Description: 20 litre undercounter mounted waste paper bin on runners. Satin stainless steel finish, with black rubber edged finger pull; Style: n/a; NominalHeight: 608 mm; NominalDepth: 379 mm; MainColor: n/a
Type - IFC - IfcExportAs: IfcFurnitureType; IfcExportType: WASTEPAPERBIN
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_50_07_96:Waste bins; CodePerformance: n/a; Color: n/a; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: Under counter mounted waste paper bin c/w runners. Brushed satin finish stainless steel. Bin fitted with black rubber edged finger pull. Bin liner hooks supplied loose; Finish: Brushed satin; Grade: n/a; Manufacturer: info@fcfrost.com; Material: Stainless steel grade 1.4301 (304); ModelNumber: 09.1150; ModelReference: Undercounter Runner Waste Bin 20 Ltr; Name: WasteBins_UndercounterRunnerWasteBin_20Ltr_FCFrostLtd; NominalWidth: 379 mm; Shape: n/a; Size: 379 x 200 x 608 mm; WarrantyDescription: This product is covered by a 12 month warranty from the date of purchase to be free from defects if installed and maintained in accordance with the products instructions. FC Frost will replace or repair (as appropriate) free of charge any product with a proven manufacturing defect if reported within the warranty period; WarrantyDurationLabor: n/a; WarrantyDurationParts: year; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyGuarantorParts: n/a
